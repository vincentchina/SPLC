# Keil uVision project KS-D01.uvprojx, settings and files
target KS-D01 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KS-D01-V0.1 +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,_STM32
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\SRAM;..\FWLIB\inc;..\HARDWARE\EXTI;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\CAN;..\HARDWARE\EXT_IO;..\HARDWARE\TC6014;..\HARDWARE\IWDG;..\HARDWARE\STMFLASH;..\..\..\PLCCore\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/EXT_IO/: ext_io.c
    ../HARDWARE/TC6014/: tc6014.c Cmc8401.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_iwdg.c stm32f4xx_flash.c
  group README
    ../: readme.txt
  group PLCCore
    ../../../PLCCore/stm32/: stm32.c
    ../../../PLCCore/core/: insClass.c MemManager.c PLCCore.c Protocol.c RunTimeError.c dataMisc.c
